## firmware/sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_MAX_PRIORITIES=32
CONFIG_ESP_WIFI_CSI_ENABLED=y
CONFIG_ESP32_WIFI_CSI_ENABLED=y
```
